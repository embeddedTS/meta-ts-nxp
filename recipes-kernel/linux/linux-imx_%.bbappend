SRCREV:tsimx = "90115ef8d6e2735bfb57ee7f8c2647ec697f999e"
SRCBRANCH:tsimx = "lf-6.12.y"
SRC_URI:tsimx = "git://github.com/embeddedTS/linux-tsimx;protocol=https;branch=${SRCBRANCH}"

IMX_KERNEL_CONFIG_AARCH64:tsimx93 = "tsimx93_defconfig"
IMX_KERNEL_CONFIG_AARCH64:tsimx95 = "tsimx95_defconfig"

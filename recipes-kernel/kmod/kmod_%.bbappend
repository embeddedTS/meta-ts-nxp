PACKAGECONFIG:append = " zstd"
PACKAGECONFIG:append:class-native = " zstd"
PACKAGECONFIG:append:class-nativesdk = " zstd"

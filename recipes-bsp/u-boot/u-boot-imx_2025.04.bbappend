UBOOT_SRC:tsimx ?= "git://github.com/embeddedTS/u-boot-imx.git;protocol=https"
SRCBRANCH:tsimx = "lf_v2025.04"
LOCALVERSION:tsimx ?= "-${SRCBRANCH}"
SRCREV:tsimx = "329c521733f15eb51b6158166b0f2737632432b9"

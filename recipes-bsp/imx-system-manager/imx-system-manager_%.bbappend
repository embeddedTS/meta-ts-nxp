IMX_SYSTEM_MANAGER_SRC:tsimx95 ?= "git://github.com/embeddedTS/ts-imx-sm.git;protocol=https"
SRCREV:tsimx95 = "f015c3c32e5a999d87b90653a1e314d93f7f4409"
